Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: e633c2d6-ac6f-48fc-a40d-5fd85994a6d5.ifc
Time: 2026-09-11T16:07:41
Author: BouwConnect Bibliotheek
Organization: De Twee Snoeken
Written by: IFC Engine DLL
Made in: BouwConnect Bibliotheek
Authorization: De Twee Snoeken

# IfcSite, Kavel
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, Bouwlaag
In: Gebouw
Elevation: 0 mm

# IfcWindow, vloerluik ongeïsoleerd enkel, uitneembaar Storax - HagoDeck BV 110, 1000x1000mm
In: Bouwlaag
Material: staal
Pset_WindowCommon - Rc-waarde: 0 m²·k/w
Pset_Data - WUID: AgAAAAmzfLYDAAAA_BYAAAV2SgAA2FMBAFJfAQDxgwAAUAgAAAIA6gcBAQAAAAEAAADlBwEBAAAAAgAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAA)); Hyperlink: https://bcb-online.nl/?WUID=AgAAAAmzfLYDAAAA_BYAAAV2SgAA2FMBAFJfAQDxgwAAUAgAAAIA6gcBAQAAAAEAAADlBwEBAAAAAgAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAA)); gewicht per st: 42 kg/st; STABU2: 43.31.10; dagmaatlengte: 1000 mm; lengte: 1135 mm; NAA.K.T: samengesteld_product_kozijn; breedte: 1135 mm; Rc-waarde: 0 m²·k/w; serie: HagoDeck; afsluitbaar: True; hoogte: 75 mm; merk: Storax; breuklast: B125; type: BV 110; dagmaatbreedte: 1000 mm; omranding: staal; luik: staal
