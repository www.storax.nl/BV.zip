Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: af657b5d-d991-451f-96c4-034a69aa510d.ifc
Time: 2026-09-11T16:07:22
Author: BouwConnect Bibliotheek
Organization: De Twee Snoeken
Written by: IFC Engine DLL
Made in: BouwConnect Bibliotheek
Authorization: De Twee Snoeken

# IfcSite, Kavel
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, Bouwlaag
In: Gebouw
Elevation: 0 mm

# IfcWindow, vloerluik ongeïsoleerd enkel, uitneembaar Storax - HagoDeck BV 108, 1000x800mm
In: Bouwlaag
Material: staal
Pset_WindowCommon - Rc-waarde: 0 m²·k/w
Pset_Data - WUID: AgAAAAmMLrYDAAAA_BYAAAV2SgAA2FMBAFJfAQDxgwAAb1oAAAIA6gcBAQAAAAEAAADlBwEBAAAAAgAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAA)); Hyperlink: https://bcb-online.nl/?WUID=AgAAAAmMLrYDAAAA_BYAAAV2SgAA2FMBAFJfAQDxgwAAb1oAAAIA6gcBAQAAAAEAAADlBwEBAAAAAgAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAA)); gewicht per st: 37 kg/st; STABU2: 43.31.10; dagmaatlengte: 1000 mm; lengte: 1135 mm; NAA.K.T: samengesteld_product_kozijn; breedte: 935 mm; Rc-waarde: 0 m²·k/w; serie: HagoDeck; afsluitbaar: True; hoogte: 75 mm; merk: Storax; breuklast: B125; type: BV 108; dagmaatbreedte: 800 mm; omranding: staal; luik: staal
