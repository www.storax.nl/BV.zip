Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: 5d75f790-2ad9-4bbe-92e1-fdb082c6f11c.ifc
Time: 2026-09-11T16:04:44
Author: BouwConnect Bibliotheek
Organization: De Twee Snoeken
Written by: IFC Engine DLL
Made in: BouwConnect Bibliotheek
Authorization: De Twee Snoeken

# IfcSite, Kavel
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, Bouwlaag
In: Gebouw
Elevation: 0 mm

# IfcWindow, vloerluik ongeïsoleerd enkel, uitneembaar Storax - HagoDeck BV 45, 450x450mm
In: Bouwlaag
Material: staal
Pset_WindowCommon - Rc-waarde: 0 m²·k/w
Pset_Data - WUID: AgAAAAk6qrYDAAAA_BYAAAV2SgAA2FMBAFJfAQDxgwAA2d4AAAIA6gcBAQAAAAEAAADlBwEBAAAAAgAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAA)); Hyperlink: https://bcb-online.nl/?WUID=AgAAAAk6qrYDAAAA_BYAAAV2SgAA2FMBAFJfAQDxgwAA2d4AAAIA6gcBAQAAAAEAAADlBwEBAAAAAgAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAA)); gewicht per st: 16 kg/st; STABU2: 43.31.10; dagmaatlengte: 450 mm; lengte: 585 mm; NAA.K.T: samengesteld_product_kozijn; breedte: 585 mm; Rc-waarde: 0 m²·k/w; serie: HagoDeck; afsluitbaar: True; hoogte: 75 mm; merk: Storax; breuklast: B125; type: BV 45; dagmaatbreedte: 450 mm; omranding: staal; luik: staal
